# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32SPIN27PS MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.4
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00003000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CORE;..\HAL_lib\inc;..\Include;..\HARDWARE;..\HARDWARE\encoder;..\HARDWARE\OLED;..\HARDWARE\LCD;..\STARTUP;..\HARDWARE\MOTOR;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\TRACE;..\HARDWARE\SPEEDCONTROL;..\HARDWARE\BLUETOOTH;..\HARDWARE\GPIO;..\HARDWARE\MPU9250;..\HARDWARE\UART;..\letter_shell\src;..\HARDWARE\BUZZER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group USER
    ./: main.c
  group HAL_lib
    ../HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group STARTUP
    ../STARTUP/: startup_MM32SPIN2xx_p.s system_MM32SPIN2xx_p.c sys.c
  group HARDWARE
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/TRACE/: trace.c
    ../HARDWARE/SPEEDCONTROL/: speedcontrol.c
    ../HARDWARE/BLUETOOTH/: bluetooth.c
    ../HARDWARE/GPIO/: GPIO.c
    ../HARDWARE/MPU9250/: angle.c SOFTI2C.c I2C_MPU9250.c
    ../HARDWARE/BUZZER/: buzzerDriver.c
    ../HARDWARE/NIMING/: data_transfer.c
    ../HARDWARE/BALANCE/: balance.c
    ../HARDWARE/HELLODATA/: hellodata.c
  group Letter-shell
    ../letter_shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
  group multi-button
    ../HARDWARE/multi_button/: multi_button.c my_multi_button.c
